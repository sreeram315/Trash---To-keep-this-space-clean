# Keil uVision project Hello world.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Hello world +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Hello_world.c
