ORG 0300H
	DB 0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H

ORG 0200H
	LOOP:
	MOV P3,#0C0H
	ACALL COUNT
	MOV P3,#0F9H
	ACALL COUNT
	MOV P3,#0A4H
	ACALL COUNT
	MOV P3,#0B0H
	ACALL COUNT
	MOV P3,#99H
	ACALL COUNT
	MOV P3,#92H
	ACALL COUNT
	MOV P3,#82H
	ACALL COUNT
	MOV P3,#0F8H
	ACALL COUNT
	MOV P3,#80H
	ACALL COUNT
	MOV P3,#90H
	ACALL COUNT
	JMP LOOP
	
	COUNT:
	L2: MOV R0,#0AH
		MOV DPTR,#0300H
		L1: CLR A
			MOVC A,@A+DPTR
			MOV P2,A
			ACALL DELAY
			INC DPTR
			DJNZ R0, L1
			SJMP L2
			
			
			DELAY: MOV R1,#0FFH
			L3:		MOV R2,#0FFH
			L4:		DJNZ R2,L4
					DJNZ R1,L3
					RET
					END