# Keil uVision project seend values.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: seend values +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 send values.c bit wise valuse giving.c sending code to port.c taking and giving from port.c 7 seg.c prac.c
    ./toggle/: toggle.asm
