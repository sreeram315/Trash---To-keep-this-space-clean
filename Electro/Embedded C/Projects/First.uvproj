# Keil uVision project First.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Atmel Atmel Wireless & uC
  output: First +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Addition.asm
