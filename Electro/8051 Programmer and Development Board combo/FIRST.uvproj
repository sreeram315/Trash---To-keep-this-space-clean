# Keil uVision project FIRST.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Atmel Atmel Wireless & uC
  output: FIRST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./8051 demo code Silicon_TechnoLab/LCD 8bit/Keil code/: main.c
    ./8051 demo code Silicon_TechnoLab/7_Segment Interrupt Based/7_segment 4 Digit/: 7_segment.c
    C:/Keil_v5/C51/Examples/HELLO/: HELLO.C
