# Keil uVision project testing.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S2051 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(20000000)
  output: testing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./proj/: jhbcajbcji.c
